Commit message: Update EPSON_LS3_B401S.urdf

File: URDFs/Robots/EPSON_LS3_B401S/EPSON_LS3_B401S.urdf (robot description, URDF)
Before this commit: robot EPSON_LS3_B401S, 6 links, 5 joints
Joints:
- joint joint_3: axis 0 0 -1 -> 0 0 1
